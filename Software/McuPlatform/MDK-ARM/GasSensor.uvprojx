# Keil uVision project GasSensor.uvprojx, settings and files
target GasSensor (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L431RCTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.1
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: GasSensor +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32L431xx
  c include: ../Core/Inc;../Drivers/STM32L4xx_HAL_Driver/Inc;../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../Drivers/CMSIS/Include;..\..\APP;..\..\Bsp;..\..\Common;..\..\Common\cJSON;..\..\Common\ringbuffer;..\..\Common\data_protocol;..\..\OperatingSystem;..\..\OperatingSystem\osal\cmsis_os;..\..\OperatingSystem\arch\arm\arm-v7m\common\include;..\..\OperatingSystem\arch\arm\arm-v7m\cortex-m4\armcc;..\..\OperatingSystem\devices\esp8266_tencent_firmware;..\..\OperatingSystem\kernel\core\include;..\..\OperatingSystem\kernel\hal\include;..\..\OperatingSystem\net\at\include;..\..\OperatingSystem\net\sal_module_wrapper;..\..\OperatingSystem\net\socket_wrapper\include;..\..\OperatingSystem\net\tencent_firmware_module_wrapper;..\..\OperatingSystem\devices\esp8266;..\..\Common\mqttclient;..\..\Common\mqttclient\common;..\..\Common\mqttclient\mqtt;..\..\Common\mqttclient\mqttclient;..\..\Common\mqttclient\network;..\..\Common\mqttclient\platform\TencentOS-tiny
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32l431xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c i2c.c usart.c spi.c stm32l4xx_it.c stm32l4xx_hal_msp.c
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_exti.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l4xx.c
  group App
    ../../APP/: App.c Model.c View.c Controller.c
  group Bsp
    ../../Bsp/: MQ_2.c Lcd.c
  group Common
    ../../Common/ringbuffer/: ring_buffer.c
    ../../Common/data_protocol/: sensor_protocol.c
    ../../Common/: Common.h
    ../../Common/cJSON/: cJSON.c
  group tos/arch
    ../../OperatingSystem/arch/arm/arm-v7m/common/: tos_cpu.c
    ../../OperatingSystem/arch/arm/arm-v7m/cortex-m4/armcc/: port_c.c port_s.S
  group tos/kernel
    ../../OperatingSystem/kernel/core/: tos_barrier.c tos_binary_heap.c tos_bitmap.c tos_char_fifo.c tos_completion.c tos_countdownlatch.c tos_event.c tos_global.c tos_mail_queue.c tos_message_queue.c tos_mmblk.c tos_mmheap.c tos_mutex.c tos_pend.c tos_priority_mail_queue.c tos_priority_message_queue.c tos_priority_queue.c tos_ring_queue.c tos_robin.c tos_rwlock.c tos_sched.c tos_sem.c tos_stopwatch.c tos_sys.c tos_task.c tos_tick.c tos_time.c tos_timer.c
  group tos/osal
    ../../OperatingSystem/osal/cmsis_os/: cmsis_os.c
  group tos/socket
    ../../OperatingSystem/net/at/src/: tos_at.c
    ../../OperatingSystem/devices/esp8266/: esp8266.c
    ../../OperatingSystem/net/socket_wrapper/: tos_at_socket.c tos_at_socket_lib.c tos_at_socket_prv.c
    ../../OperatingSystem/net/sal_module_wrapper/: sal_module_wrapper.c
  group tos/hal
    ../../OperatingSystem/platform/hal/st/stm32l4xx/src/: tos_hal_uart.c
  group tos/config
    ../../OperatingSystem/: tos_config.h
  group mqttclient
    ../../Common/mqttclient/mqttclient/: mqttclient.c
  group mqttclient/mqtt
    ../../Common/mqttclient/mqtt/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
  group mqttclient/common
    ../../Common/mqttclient/common/: mqtt_list.c random.c
  group mqttclient/network
    ../../Common/mqttclient/network/: nettype_tcp.c nettype_tls.c network.c
  group mqttclient/platform
    ../../Common/mqttclient/platform/TencentOS-tiny/: platform_memory.c platform_mutex.c platform_net_socket.c platform_thread.c platform_timer.c
  group mqttclient/config
    ../../Common/mqttclient/: mqtt_config.h
software components: CMSIS:CORE 4.3.0
